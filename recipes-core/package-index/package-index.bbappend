do_package_index[depends] += "areadeltasat-enigma2-image:do_image_complete"
