SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Quadri-9-13-16-19-est"

include settings-vhannibal.inc
