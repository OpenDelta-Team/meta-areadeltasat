SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Quadri-Multistream"

include settings-vhannibal.inc
