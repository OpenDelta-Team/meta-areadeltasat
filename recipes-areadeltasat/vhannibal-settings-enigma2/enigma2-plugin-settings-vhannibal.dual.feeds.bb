SUMMARY = "Vhannibal Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "Dual-Feeds"

include settings-vhannibal.inc
