SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Quadri-Turk"

include settings-vhannibal.inc
