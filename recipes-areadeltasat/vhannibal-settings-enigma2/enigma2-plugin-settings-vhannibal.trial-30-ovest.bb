SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Trial-30-ovest"

include settings-vhannibal.inc
