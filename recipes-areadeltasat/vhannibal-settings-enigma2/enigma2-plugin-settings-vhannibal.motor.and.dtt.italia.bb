SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "Motor-Dtt-Italia"

include settings-vhannibal.inc
