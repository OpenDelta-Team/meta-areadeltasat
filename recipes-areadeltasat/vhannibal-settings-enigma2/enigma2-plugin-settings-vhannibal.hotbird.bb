SUMMARY = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "HotBird"

include settings-vhannibal.inc
