SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "Motor"

include settings-vhannibal.inc
