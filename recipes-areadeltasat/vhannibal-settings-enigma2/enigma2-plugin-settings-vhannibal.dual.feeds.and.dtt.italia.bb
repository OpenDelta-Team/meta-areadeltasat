SUMMARY = "Vhannibal Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "Dual-Feeds-Dtt-Italia"

include settings-vhannibal.inc
