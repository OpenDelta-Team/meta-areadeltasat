SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Quadri-13-19-23-28-est"

include settings-vhannibal.inc
