SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Hot-Bird-Dtt-Italia"

include settings-vhannibal.inc
