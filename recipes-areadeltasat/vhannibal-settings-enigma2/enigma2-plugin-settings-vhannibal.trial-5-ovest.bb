SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Trial-5-ovest"

include settings-vhannibal.inc
