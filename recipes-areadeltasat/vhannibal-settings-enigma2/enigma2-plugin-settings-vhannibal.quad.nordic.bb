SUMMARY = "Vhannibal E2 Settings File"

SETTINGS_FILENAME = "Quadri-Nordic"

include settings-vhannibal.inc
